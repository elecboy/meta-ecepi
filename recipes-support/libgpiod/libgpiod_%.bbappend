PACKAGECONFIG:append = " python3"


