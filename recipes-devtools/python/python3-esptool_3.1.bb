inherit setuptools3
require python-esptool.inc
