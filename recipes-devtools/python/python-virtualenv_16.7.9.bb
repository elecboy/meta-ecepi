inherit pypi setuptools
require python-virtualenv.inc
