inherit pypi setuptools3
require python-virtualenv.inc
