inherit pypi setuptools3
require python-esptool.inc
DEPENDS += "\
    ${PYTHON_PN}-wheel-native \
"
